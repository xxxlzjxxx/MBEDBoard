<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\F5438A_MINI_V10A_MSP430-SV10_160711_D.ewp</path>
  </project>
  <batchBuild/>
</workspace>


